# Keil uVision project gd32f4.uvprojx, settings and files
target gd32f4 (6210000::V6.21::ARMCLANG)
  device: GD32F427VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\application;..\library\include;..\start;..\rc522
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../application/: main.c gd32f4xx_it.c gd32f4xx_it.h
  group library
    ../library/source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group start
    ../start/: core_cm4.h core_cm4_simd.h core_cmInstr.h core_cmFunc.h startup_gd32f407_427.s system_gd32f4xx.h system_gd32f4xx.c gd32f4xx.h
    ../application/: gd32f4xx_libopt.h
  group rc522
    ../rc522/: hw_spi.c hw_spi.h my_uart.c my_uart.h rc522.c rc522.h systick.c systick.h 485Port.c 485Port.h
